# Keil uVision project BitBanging_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: BitBanging_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h DataLine_aliases.h DataLine.c DataLine.h ClockLine_aliases.h ClockLine.c ClockLine.h FREX_aliases.h FREX.c FREX.h EXPST_aliases.h EXPST.c EXPST.h XCLK_aliases.h XCLK.c XCLK.h PWND_aliases.h PWND.c PWND.h RST_B_aliases.h RST_B.c RST_B.h Clock_1.c Clock_1.h LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c LCD_Char_1_LCDPort_aliases.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h DataBus_aliases.h DataBus.c DataBus.h PCLK_aliases.h PCLK.c PCLK.h VREF_aliases.h VREF.c VREF.h HREF_aliases.h HREF.c HREF.h isr_PCLK.c isr_PCLK.h isr_VREF.c isr_VREF.h isr_HREF.c isr_HREF.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: BitBanging_PSoC5lib (library)
