# Keil uVision project Design01_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Design01_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h USB.c USB.h USB_audio.c USB_audio.h USB_boot.c USB_cdc.c USB_cdc.h USB_cls.c USB_descr.c USB_drv.c USB_episr.c USB_hid.c USB_hid.h USB_pm.c USB_std.c USB_vnd.c USB_cdc.inf USB_midi.c USB_midi.h USB_Dm_aliases.h USB_Dm.c USB_Dm.h USB_Dp_aliases.h USB_Dp.c USB_Dp.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Design01_PSoC5lib (library)
